<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AMicArray_Acoustic_SL.ewp</path>
  </project>
  <batchBuild/>
</workspace>


