# Keil uVision project MicrophonesStreaming.uvprojx, settings and files
target OnBoardMics (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L4R9ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: OnBoardMics +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L4R9xx,USE_USB_FS,ARM_MATH_CM4
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/STWIN;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/CMSIS/DSP/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/User
    ../Src/: audio_application.c cube_hal_l4.c main.c stm32xx_it.c usbd_audio_if.c usbd_conf_l4.c usbd_desc.c
    ../Patch/: stm32l4xx_hal_pcd_patch.c
  group Drivers/BSP/STWIN
    ../../../../../Drivers/BSP/STWIN/: STWIN.c STWIN_audio.c STWIN_bus.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/STM32_USBD_Library/Class/AUDIO_IN
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio_in.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 5.3.0
