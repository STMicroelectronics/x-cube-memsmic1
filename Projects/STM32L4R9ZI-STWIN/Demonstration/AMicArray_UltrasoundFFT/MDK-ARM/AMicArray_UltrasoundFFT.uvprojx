# Keil uVision project AMicArray_UltrasoundFFT.uvprojx, settings and files
target STWIN-MEMSMIC1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L4R9ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x81FFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM(0x0-0xFFFFFFFFFFFFFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM3(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IRAM(0x0-0xFFFFFFFFFFFFFFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM3(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: AMicArray_UltrasoundFFT +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,ARM_MATH_CM4
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STWIN;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/parson;../../../../../Drivers/BSP/Components/adau1978;../../../../../Drivers/BSP/MicArrayCoupon;../../../../../Middlewares/ST/STM32_GenericFFT_Library/Inc;..\..\..\..\..\Drivers\CMSIS\DSP\Include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xae032f0d size 0xc77d7f7
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/User
    ../Src/: AMic_Array_app.c com_manager.c device_description.c fft_app.c HSD_json.c main.c sensors_manager.c stm32l4xx_it.c usbd_conf.c usbd_desc.c usbd_wcid_interface.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/adau1978/: adau1978.c adau1978_reg.c
  group Drivers/BSP/MicArrayCoupon
    ../../../../../Drivers/BSP/MicArrayCoupon/: AMic_Array_audio.c
  group Drivers/BSP/STWIN
    ../../../../../Drivers/BSP/STWIN/: STWIN.c STWIN_bc.c STWIN_bus.c STWIN_debug_pins.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/CMSIS/DSP/Lib
    ../../../../../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB/Class/WCID
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Src/: usbd_wcid_streaming.c
  group Middlewares/USB/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_GenericFFT_Library
    ../../../../../Middlewares/ST/STM32_GenericFFT_Library/Src/: fft.c
software components: CMSIS:CORE 5.6.0
