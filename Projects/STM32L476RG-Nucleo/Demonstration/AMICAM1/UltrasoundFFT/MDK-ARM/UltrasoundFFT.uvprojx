# Keil uVision project UltrasoundFFT.uvprojx, settings and files
target STM32L476RG-MEMSMIC1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x80FFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM(0x0-0xFFFFFFFFFFFFFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM3(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IRAM(0x0-0xFFFFFFFFFFFFFFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM3(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UltrasoundFFT +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,ARM_MATH_CM4
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Drivers/BSP/AMICAM1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/ad1974;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/parson;../../../../../../Middlewares/ST/STM32_GenericFFT_Library/Inc;..\..\..\..\..\..\Drivers\CMSIS\DSP\Include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xae032f0d size 0xc77d7f7
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: amicam1_app.c com_manager.c device_description.c fft_app.c HSD_json.c main.c sensors_manager.c stm32l4xx_nucleo_bus.c stm32xx_it.c usbd_conf.c usbd_desc.c usbd_wcid_interface.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ad1974/: ad1974.c ad1974_reg.c
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-AMICAM1
    ../../../../../../Drivers/BSP/AMICAM1/: amicam1_audio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/CMSIS/DSP/Lib
    ../../../../../../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Middlewares
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/STM32_USB_Device_Library/Class/WCID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/SensorStreaming_WCID/Src/: usbd_wcid_streaming.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_GenericFFT_Library
    ../../../../../../Middlewares/ST/STM32_GenericFFT_Library/Src/: fft.c
software components: CMSIS:CORE 5.6.0
