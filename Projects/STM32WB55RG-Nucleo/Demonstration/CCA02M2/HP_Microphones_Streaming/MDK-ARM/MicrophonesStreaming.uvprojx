# Keil uVision project MicrophonesStreaming.uvprojx, settings and files
target STM32WB55-MEMSMIC1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2002FFFF) IRAM2aRet_SHARED(0x20030000-0x200327FF) IRAM2b_SHARED(0x20038000-0x2003CFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32WB55-MEMSMIC1 +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_STM32WBXX_NUCLEO,USE_USB_FS,CORE_CM4,ARM_MATH_CM4
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HP_AUDIO/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Drivers/BSP/CCA02M2;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_Audio/Addons/HP_PDM/Inc;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/: audio_application.c cube_hal_wb.c main.c stm32xx_it.c usbd_audio_if.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/X-NUCLEO-CCA02M2
    ../../../../../../Drivers/BSP/CCA02M2/: cca02m2_audio.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_sai.c stm32wbxx_hal_sai_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_spi.c
  group Middlewares/ST/STM32_Audio/HP_PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/HP_PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/ST/STM32_USB_Device_Library/Class/HP_AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HP_AUDIO/Src/: usbd_audio_in.c
  group Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0
