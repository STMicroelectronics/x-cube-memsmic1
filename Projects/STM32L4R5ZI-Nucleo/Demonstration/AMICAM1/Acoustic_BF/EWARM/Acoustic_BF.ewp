# IAR project Acoustic_BF.ewp, settings and files
configuration STM32L4R5ZI-MEMSMIC1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R5ZI ST STM32L4R5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4R5xx; USE_STM32L4XX_NUCLEO; USE_USB_FS; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Drivers\BSP\AMICAM1; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\ad1974; ..\..\..\..\..\..\Middlewares\ST\STM32_AcousticBF_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_AcousticBF_Library\Src; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Acoustic_BF.bin
  ILINK.IlinkOutputFile: Acoustic_BF.out
  ILINK.IlinkIcfFile: stm32l4r5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l4r5xx.s
  group Application/User
    ../Src/: audio_application.c cube_hal_l4.c main.c stm32l4xx_nucleo_bus.c stm32xx_it.c usbd_audio_if.c usbd_conf_l4.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ad1974/: ad1974.c ad1974_reg.c
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-AMICAM1
    ../../../../../../Drivers/BSP/AMICAM1/: amicam1_audio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Middlewares/STM32_AcousticBF_Library
    ../../../../../../Middlewares/ST/STM32_AcousticBF_Library/Src/: acousticBF.c
  group Middlewares/STM32_Audio
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_IAR_wc32.a
  group Middlewares/STM32_USB_Device_Library/Class/AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio_in.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
